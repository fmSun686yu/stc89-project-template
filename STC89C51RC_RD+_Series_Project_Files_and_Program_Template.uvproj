# Keil uVision project STC89C51RC_RD+_Series_Project_Files_and_Program_Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: STC89C51RC_RD+_Series_Project_Files_and_Program_Template +hex
  c flags: Optimize=8 SizeSpeed=1
